# Keil uVision project BH-F103.uvprojx, settings and files
target USART (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\BSP\debug_usatr1;..\..\User\call_send_mode_change;..\..\BSP\gsm_usart2;..\..\User\gsm_usart2_data_processing;..\..\BSP\systick;..\..\BSP\basetime
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/call_send_mode_change/: call_send_mode_change.c call_send_mode_change.h
    ../../User/gsm_usart2_data_processing/: gsm_usart2_data_processing.c gsm_usart2_data_processing.h
  group BSP
    ../../BSP/debug_usatr1/: bsp_debug_usart1.c bsp_debug_usart1.h
    ../../BSP/gsm_usart2/: bsp_gsm_usart2.c bsp_gsm_usart2.h
    ../../BSP/systick/: bsp_systick.c bsp_systick.h
    ../../BSP/basetime/: bsp_basetime.c bsp_basetime.h
